<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\Programing\Stm8s\Code\BlinkLed\Project\Blink_Led.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Programing\Stm8s\Code\Encoder\Project\Encoder.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LOCKVT.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Programing\Stm8s\Code\std_library\STM8S_StdPeriph_Lib\Project\STM8S_StdPeriph_Template\EWSTM8\Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
